# IAR project AlarmWakeUp.ewp, settings and files
configuration N32G4FR (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32g4fr_std_periph_driver/inc; ../../../../bsp/inc; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/CMSIS/core; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AlarmWakeUp.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G4FR\N32G4FRxE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_usart.c n32g4fr_wwdg.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group USER
    ../src/: main.c n32g4fr_it.c User_Delay_Config.c User_LED_Config.c User_RTC_Config.c
