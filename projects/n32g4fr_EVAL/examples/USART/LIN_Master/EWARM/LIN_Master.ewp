# IAR project LIN_Master.ewp, settings and files
configuration N32G4FR (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32g4fr_std_periph_driver/inc; D:\linfuliang_work\pro\NS3601\code\2.2.0\Nationstech.N32G4FR_Library.2.2.0\projects\n32g4fr_EVAL\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LIN_Master.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G4FR\N32G4FRxE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group USER
    ../../../../bsp/src/: delay.c log.c
    ../src/: lin_master.c main.c n32g4fr_it.c
