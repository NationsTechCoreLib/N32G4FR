# Keil uVision project LIN_Master.uvprojx, settings and files
target N32G4FR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.5
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LIN_Master +hex
  AfterMake: fromelf --bin --output=.\bin\LIN_Master.bin .\Objects\LIN_Master.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\LIN_Master.axf --output=.\bin\LIN_Master.dua
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c
  group USER
    ../../../../bsp/src/: log.c delay.c
    ../src/: main.c n32g4fr_it.c lin_master.c
  group DOC
    ../: readme.txt
